# Keil uVision project util.uvprojx, settings and files
target cm0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: util_cm0 (library)
  AfterMake: cmd.exe /C copy .keil\cm0\Objects\util_cm0.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: Array.h ArrayMap.h ArrayMapPrototype.cpp ArrayMapPrototype.h ArrayPrototype.cpp ArrayPrototype.h ArrayQueue.h ArrayQueuePrototype.cpp ArrayQueuePrototype.h Base64.cpp Base64.h Collection.h CommandExecutor.cpp CommandExecutor.h CommandHandler.h CommandHandlerDefaultHelp.cpp CommandHandlerDefaultHelp.h CommandHandlerEvent.cpp CommandHandlerEvent.h CommandHandlerMethod.h Iterator.h Map.h package-info.h Pool.h Queue.h README.md Scanner.cpp Scanner.h Updater.h Future.cpp Future.h
target cm3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: util_cm3 (library)
  AfterMake: cmd.exe /C copy .keil\cm3\Objects\util_cm3.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cm4f (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: util_cm4f (library)
  AfterMake: cmd.exe /C copy .keil\cm4f\Objects\util_cm4f.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
